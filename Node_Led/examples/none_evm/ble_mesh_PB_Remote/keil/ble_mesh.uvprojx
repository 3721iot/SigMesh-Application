# Keil uVision project ble_mesh.uvprojx, settings and files
target ble_mesh (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: ble_mesh
  AfterMake: fromelf.exe  --text  -c -o Output/ble_mesh.txt  Objects/ble_mesh.axf
  AfterMake: fromelf.exe  --bin -o Output/ble_mesh.bin  Objects/ble_mesh.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\components\ble\include;..\..\..\..\components\driver\include;..\..\..\..\components\modules\os\include;..\..\..\..\components\modules\sys\include;..\..\..\..\components\modules\platform\include;..\..\..\..\components\modules\common\include;..\..\..\..\components\modules\lowpow\include;..\..\..\..\components\modules\button;..\..\..\..\components\modules\sha256;..\..\..\..\components\modules\aes_cbc;..\..\..\..\components\ble\include\gap;..\..\..\..\components\ble\include\gatt;..\..\..\..\components\ble\include\mesh;..\..\..\..\components\ble\profiles\ble_ota;..\code;..\userapp\int
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\ble_5_0.sct
  link misc: --feedback=feedback.txt ../../../../components/ble/library/syscall.txt --entry=app_main --keep=_jump_table_reserved --keep=_jump_table_version --keep=_jump_table_image --keep=_jump_table_middle --keep=_jump_table_last --datacompressor=off
  group application
    ../code/: proj_main.c user_task.c mesh_model_msg.c pb_remote_central.c sig_mesh_info.c sig_mesh_led.c app_at.c ble_simple_peripheral.c simple_gatt_service.c
    ../../../../components/modules/button/: button.c
  group driver
    ../../../../components/driver/: driver_codec.c driver_efuse.c driver_i2s.c driver_iic.c driver_keyscan.c driver_pmu.c driver_pmu_pwm.c driver_pmu_qdec.c driver_ssp.c driver_timer.c driver_wdt.c driver_rtc.c driver_exti.c driver_uart.c driver_pwm.c
  group platform
    ../../../../components/modules/platform/source/: core_cm3_isr.c app_boot_vectors.s
  group patch
    ../../../../components/modules/patch/: patch.c
  group lib
    ../../../../components/ble/library/: fr8010h_stack_pb_remote.lib
  group module
    ../../../../components/modules/sha256/: sha256.c
    ../../../../components/modules/aes_cbc/: aes_cbc.c
  group userapp
    ../userapp/src/: led_fun.c
  group kv
    ../code/: kvmgr.c
software components: CMSIS:CORE 5.6.0
